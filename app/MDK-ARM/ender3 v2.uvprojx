# Keil uVision project ender3 v2.uvprojx, settings and files
target ender3 v2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8008000-0x8077FFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ender3 v2 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  AfterMake: keil-build-viewer.exe
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Banux;../Banux/00_core;../Banux/01_driver;../Banux/01_driver/eeprom;../Banux/01_driver/internal_flash;../Banux/01_driver/sd;../Banux/01_driver/stepper;../Banux/01_driver/timer;../Banux/01_driver/uart;../Banux/inc;../Banux/02_system_components/file_io;../Banux/02_system_components/command_line;../Banux/02_system_components/command_parser;../Banux/02_system_components/event;../Banux/02_system_components/internal_flash_fs;../Banux/02_system_components/fatfs/app;../Banux/02_system_components/fatfs/target;../Banux/02_system_components/fatfs/src;../Banux/02_system_components/fatfs/src/drivers;../Banux/02_system_components/driver_framework;../Banux/02_system_components/driver_framework/core;../Banux/02_system_components/driver_framework/vfs;../Banux/03_application_components/motion_control;../Banux/03_application_components/gcode;../Banux/03_application_components/wireless_control
  memory RVCT4: ROM 0x8008000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c sdio.c usart.c app_bl.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/Banux
    ../Banux/00_core/: Banux.c banux_component.c banux_scheduler.c banux_debug.c
    ../Banux/02_system_components/file_io/: banux_io.c
    ../Banux/02_system_components/driver_framework/vfs/: vfs.c
    ../Banux/02_system_components/driver_framework/: drv_init.c
    ../Banux/02_system_components/driver_framework/core/: drv_fs.c drv_device.c
    ../Banux/02_system_components/command_line/: bg_shell.c bg_shell_commands.c shell_io_uart.c
    ../Banux/01_driver/sd/: drv_sdio.c fs_sd.c
    ../Banux/01_driver/internal_flash/: internal_flash_diskio.c
    ../Banux/01_driver/uart/: drv_uart.c
    ../Banux/01_driver/eeprom/: drv_eeprom.c
    ../Banux/01_driver/stepper/: drv_stepper.c
    ../Banux/01_driver/hc245/: drv_hc245.c
    ../Banux/02_system_components/event/: component_manifest.c bg_event.c
    ../Banux/03_application_components/firmware_upgrade/: component_manifest.c
    ../Banux/02_system_components/command_parser/: command_parser.c
    ../Banux/01_driver/timer/: drv_timer1ms.c
    ../Banux/01_driver/: driver_init.c
    ../Banux/02_system_components/internal_flash_fs/: internal_flash_fs.c
    ../Banux/03_application_components/gcode/: gcode.c
    ../Banux/03_application_components/wireless_control/: wireless_control.c
    ../Banux/03_application_components/motion_control/: motion_control.c
  group Application/User/Banux/FatFs/Target
    ../Banux/02_system_components/fatfs/target/: bsp_driver_sd.c
  group Application/User/Banux/FatFs/App
    ../Banux/02_system_components/fatfs/app/: fatfs.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_mmc.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/User/Banux/FatFs/Core
    ../Banux/02_system_components/fatfs/src/: diskio.c ff.c ff_gen_drv.c
    ../Banux/02_system_components/fatfs/src/option/: syscall.c ccsbcs.c
    ../Banux/02_system_components/fatfs/src/drivers/: sd_diskio.c
software components: CMSIS:CORE 4.3.0
